<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STSW-FSM01M1.ewp</path>
  </project>
  <batchBuild />
</workspace>
